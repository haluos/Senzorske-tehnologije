# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c include: .\; Lib\CMSIS\Include; Lib\CMSIS\Device\ST\STM32F4xx\Include;Lib\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ./: stm32f4xx_conf.h
    ./Lib/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
    ./Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM_Lib
    ./: Template.lib
  group Source
    ./: main.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c misc.c stm32f4xx_dma.c packing.c dataOrganization.c usart.c dma.c timer.c Delay.c DS18B20.c LM35DZ.c TMP101.c MAX6675.c MAX6682.c PWM.c
  group Header
    ./: main.h stm32f4xx.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_usart.h misc.h stm32f4xx_dma.h packing.h dataOrganization.h defines.h usart.h dma.h timer.h Delay.h DS18B20.h LM35DZ.h TMP101.h MAX6675.h MAX6682.h PWM.h
software components: CMSIS:CORE 5.0.1
